FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH = "trt-only-logo"
SRC_URI += "file://trt-only-logo.png;name=psplash-logo"
